# Keil uVision project Infantry2nd_gimbal.uvprojx, settings and files
target Infantry2nd (ARM-ADS)
  device: STM32F427II STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Infantry2nd_gimbal
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F427_437xx
  c include: ..\FWLIB\inc;..\CORE;..\FREERTOS\Source\include;..\USER;..\TASKS;..\BSP;..\BSP\Init;..\BSP\LED;..\BSP\FIFO;..\BSP\IMU;..\BSP\Delay;..\BSP\Timer;..\BSP\Can;..\BSP\Usart;..\BSP\Flash;..\BSP\SysTick;..\BSP\Pid;..\BSP\Ramp;..\BSP\SysParam;..\BSP\CrcCheck;..\BSP\Encoder
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../USER/: main.c includes.h FreeRTOSConfig.h
  group Bsp
    ../BSP/Init/: bsp_init.c
    ../BSP/SysTick/: SysTime.c
    ../BSP/LED/: led.c
    ../BSP/Can/: bsp_can1.c bsp_can2.c
    ../BSP/Flash/: bsp_flash.c
    ../BSP/Timer/: bsp_timer1.c bsp_timer2.c bsp_timer5.c bsp_timer6.c bsp_timer12.c
    ../BSP/Usart/: bsp_usart1.c Bsp_usart3.c bsp_usart6.c
  group Imu
    ../BSP/IMU/: mpu6500_driver.c mpu6500_int.c mpu6500_spi.c
  group Common
    ../BSP/Pid/: pid_regulator.c
    ../BSP/Ramp/: ramp.c
    ../BSP/FIFO/: fifo.c
    ../BSP/Delay/: delay.c
    ../BSP/SysParam/: param.c
    ../BSP/CrcCheck/: MF_CRC16.c MF_CRC8.c
    ../BSP/Encoder/: encoder.c
  group Tasks
    ../TASKS/: Led_Task.c SysInfo_Task.c DataSend_Task.c IMU_Task.c Remote_Task.c GimbalCtrl_Task.c ShooterCtrl_Task.c Protocol_Task.c
  group Core
    ../CORE/: system_stm32f4xx.c stm32f4xx.h core_cm4.h startup_stm32f427x.s
    ../FWLIB/inc/: stm32f4xx_conf.h
  group FwLib
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group FreeRTOS
    ../FREERTOS/Source/: list.c queue.c tasks.c timers.c event_groups.c
    ../FREERTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../FREERTOS/Source/portable/MemMang/: heap_4.c
    ../FREERTOS/Source/include/: FreeRTOS.h portmacro.h
